# Keil uVision project STC_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: STC_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER
  group Source Group 1
    ./: STARTUP.A51
    ../USER/: main.c
