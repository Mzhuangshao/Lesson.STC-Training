# Keil uVision project KEY-test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT83/87C5112 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: KEY-test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group Source Group 1
    ./: STARTUP.A51
    ./user/: main.c
  group KEY
    ./user/: BitMap.c Bleep.c KEY.c LED.c SysLed.c timer.c
