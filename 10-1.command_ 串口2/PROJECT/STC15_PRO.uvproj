# Keil uVision project STC15_PRO.uvproj, settings and files
target 2 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: STC15_PRO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER
  group USER
    ./: STARTUP.A51
    ../USER/: main.c
  group BSP
    ../USER/: Timer.c SysLed.c Buzzer.c DotLed.c LSD.c Uart.c command.c
