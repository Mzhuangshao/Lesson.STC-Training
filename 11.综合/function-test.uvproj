# Keil uVision project function-test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT83/87C5111 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x0FFF) CLOCK(33000000) MODP2
  output: function-test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group Source Group 1
    ./: STARTUP.A51
    ./user/: main.c LED.c
  group function
    ./user/: BitMap.c SysLed.c Timer.c Bleep.c KEY.c
