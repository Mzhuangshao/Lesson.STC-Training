# Keil uVision project timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: timer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user
  group Source Group 1
    ./: STARTUP.A51
    ../user/: timer5.c timer3.c
