# Keil uVision project IO.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT83C5135 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FFF) CLOCK(24000000) MODP2
  output: IO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group Source Group 1
    ./: STARTUP.A51
    ./user/: main.c
  group IO
    ./user/: BitMap.c Bleep.c LED.c SysLed.c timer.c Uart.c
