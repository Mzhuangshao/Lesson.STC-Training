# Keil uVision project muilt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: muilt +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user
  group Source Group 1
    ./: STARTUP.A51
    ./user/: main.c
  group TEST
    ./user/: timer.c SysLed.c BitMap.c Bleep.c P0.c
