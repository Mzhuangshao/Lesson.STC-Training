# Keil uVision project BDSH.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BDSH +hex
  c flags: SizeSpeed=1
  c include: ..\USER
  group USER
    ./: STARTUP.A51
    ../USER/: main.c
  group BSP
    ../USER/: Timer.c Sysled.c Buzzer.c Dotled.c ben.c rad.c
