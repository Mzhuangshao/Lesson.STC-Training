# Keil uVision project function.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C1051 Atmel
  cpu: IRAM(0 - 0x3F) IROM(0 - 0x3FF) CLOCK(24000000)
  output: function +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
  group New Group
    ../user/: BitMap.c Bleep.c KEY.c LED.c SysLed.c Timer.c
