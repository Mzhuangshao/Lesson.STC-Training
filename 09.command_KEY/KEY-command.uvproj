# Keil uVision project KEY-command.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: KEY-command
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./user/: main.c
  group KEY
    ./user/: timer.c BitMap.c button.c Bleep.c LED.c SysLed.c
